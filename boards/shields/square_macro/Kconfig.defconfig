## boards/shields/square_macro/Kconfig.defconfig
```kconfig
if SHIELD_SQUARE_MACRO

config ZMK_KEYBOARD_NAME
    default "square_macro"

endif
```
